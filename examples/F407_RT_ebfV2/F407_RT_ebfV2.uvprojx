# Keil uVision project F407_RT_ebfV2.uvprojx, settings and files
target F407_RT (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Projects\app\inc;.\Projects\board\inc;.\Projects\bsp\inc;.\Projects\bsp;.\Projects\CMSIS\cortexm4;.\Projects\CMSIS\mcu;.\Projects\config;.\Projects\kernel\include;.\Projects\kernel\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./Projects/app/src/: main.c test_peripherals.c test_runner.c
  group config
    ./Projects/config/: f407_rt_config.h f407_rt_modules.h
  group board
    ./Projects/board/src/: board.c
    ./Projects/board/inc/: board.h
  group bsp
    ./Projects/bsp/: drv_config.h
    ./Projects/bsp/src/: drv_adc.c drv_dac.c drv_dma.c drv_exti.c drv_gpio.c drv_i2c.c drv_pwr.c drv_rcc.c drv_rtc.c drv_sdio.c drv_spi.c drv_tim.c drv_usart.c drv_wdg.c drv_can.c drv_crc.c drv_cryp.c drv_dbgmcu.c drv_dcmi.c drv_eth.c drv_flash.c drv_fsmc.c drv_hash.c drv_i2s.c drv_nvic.c drv_rng.c drv_scb.c drv_syscfg.c drv_systick.c drv_usb_otg_fs.c drv_usb_otg_hs.c drv_wwdg.c
  group CMSIS
    ./Projects/CMSIS/src/: system_stm32f4xx.c
  group kernel
    ./Projects/kernel/bsp/: rtconfig.h
    ./Projects/kernel/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ./Projects/kernel/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group startup
    ./Projects/startup/: startup_stm32f407xx.s
    ./Objects/: rt_demo.sct
